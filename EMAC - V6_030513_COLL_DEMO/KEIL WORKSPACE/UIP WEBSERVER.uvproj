# Keil uVision project UIP WEBSERVER.uvproj, settings and files
target LPC17xx Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: smart_home +hex
  c flags: Optim=1
  c define: _MCB1700_
  c include: .;..\..\COMMON\INC;..\APP\INC;..\DRIVERS\UIP_WEBSERVER\INC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Source
    ../DRIVERS/UIP_WEBSERVER/SRC/: clock-arch.c httpd.c httpd-cgi.c httpd-fs.c http-strings.c psock.c tapdev.c timer.c uip.c uip_arp.c lpc17xx_systick.c lpc17xx_emac.c scad_app.c uart.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_pinsel.c
    ../APP/SRC/: main.c
  group Startup
    ../../COMMON/SRC/: startup_LPC17xx.s
  group Common
    ../../COMMON/SRC/: system_LPC17xx.c
target LPC17xx RAM (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: USBCDC +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x8000
